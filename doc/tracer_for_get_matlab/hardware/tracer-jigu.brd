# Repository taizo-d3s/aboutme_and_mylogs

File README.md:

# aboutme_and_mylogs
ここに最新の私DDDSの情報を集めていく

# about me

**組み込みシステム開発・ITエンジニア**

2002年から個人事業主として仕事してます。SoftからHardまでDirectにデキるエンジニアです。生涯現役を目指します!!

1. ファームウェア設計
2. FPGAロジック設計
3. 回路設計・アートワーク・基板設計
4. （シンプルな)機構設計・ロボット制作

* 屋号名：Direct Digital Design and Services
* 現住所：東京都豊島区東池袋

# docs

- [M5ATOMでDualShock4を動かす](https://github.com/taizo-d3s/aboutme_and_mylogs/tree/main/doc/m5atom_DUALSHOCK4/README.md)
- [RP2040(いわいるRasPico)で、お手軽に（＝なるだけ時間をかけずに）実用(!?)なモノを作る](https://github.com/taizo-d3s/aboutme_and_mylogs/blob/main/doc/RP2040/README.md)
- [ロボトレーサを作る](https://github.com/taizo-d3s/aboutme_and_mylogs/blob/main/doc/tracer_for_get_matlab/README.md)
- [名刺基板](https://github.com/taizo-d3s/aboutme_and_mylogs/tree/main/doc/namecard_atsam_arduino)
- (extra)[古いLCDをリサイクルに出す](https://github.com/taizo-d3s/aboutme_and_mylogs/blob/main/doc/recycle/README.md)
# members of organization
- [EATEC 電気通信大学企業家懇話会](http://eatec.org/biz/)

# Contact
taizo_d3s@digientity.com

## EAGLE design doc/tracer_for_get_matlab/hardware/tracer-jigu.brd

File doc/tracer_for_get_matlab/README.md:

# ロボトレーサを作る 
 
## プリアンブル

　運命に引き寄せらるがごとく、ロボトレーサを作ることにする。ちょうどネット上で倒立振子を作っている人(
[かーたーさん](https://qiita.com/Carter)）をフォローして、真似してモノを作ろうとしていたところ、買ったモータがよく観れば大御所[アニキ](http://anikinonikki.cocolog-nifty.com/blog/)の[トレーニングトレーサー](https://github.com/rt-net/TrainingTracer_Hardware)と同形状じゃないですか？　これを**運命**と言わずになんというのだろう。とりあえずarduino megaで試作したら、マイクロマウサー向けのmatlabライセンス（**ヴィジュアル言語に絶対に手を出すなっとじっちゃに言われているのに**）を申請して、電源ベース3.3VでESP32でもう一回作ろうっと!!

## ブロック図を書いて構想を練る

## 勢いで回路図書いて発注しちゃう

- 前回作った倒立振子用のATMEGA基板でSimulink関係のデバッグを終え、とりあえずそれをコピペして作ってみた。やっつけで作ったので後はハードデバッグしながら進める
- あとATMEGAはDTRでリセットをかける知見を得たので、BT経由でDTRを操作できる(←こちらも実ハードで確認した、ただしモジュールが一個しかない。。。)RN42の焼き焼き基板も作ってみる。これがうまく動けば、無線エクスターナルモードが出来て非常に楽しくなる（はたしてうまく行くか。。。）
 
- 相変わらずJLPCB（円安にも負けず）安い。次はPCBAまで挑戦したい（CADはJLPCB提供のツールを使ってみる）

## TODO
- ジャンパの情報をちゃんと乗っける
- EAGLE

## 作業LOG

- 2022.0627:秋月で部品だけ発注
- 2022.0628:このログを描き始めて、ちょっとしたブロック図を書く
- 2022.07.21:回路図書いてレイアウトして発注しちゃう
- 2022.07.31:基板到着
- 2022.08.05:ハードデバッグ開始
- 2022.08.07:線の引き忘れ多数発見、めっちゃへこむ
- 2022.08.27:初めての走行＆初めてのライントレース（5秒だけ）
 1. [初めての走行](https://user-images.githubusercontent.com/19498503/189788196-155438ce-a368-418a-bf86-845df37a878d.mp4)
 2. [初めてのライントレース](https://user-images.githubusercontent.com/19498503/189788262-faa30739-ced6-4a80-b38b-f4e3951d2a1c.mp4)
- （今ここ）2022.09.13: ハードデバッグも済んで、コードをいじり始めているが限界（MATLABコードだけだと厳しい）なのでS-functionを調査してみたりする。

## おわりに

　みんなアニキ大好き💛

Parts:
+5V: TP-HOLE
C1, C3: 0.1; 1608NEW
C2: 30p; 1608NEW
C4: (PAS)C[3216]; 3216
CPU_RX1: TP-HOLE
CPU_TX1: TP-HOLE
GND: TP-HOLE
IC1: RN-42-BT; RN42-BT-PAC
IC2: (3.3V)NJM2884U1-33-TE1; SOT-89-5-1
MEGA_RST: TP-HOLE
R1: 4.7k; 1608NEW
R2: 2.2k; 1608NEW
R3: 3.3k; 1608NEW

Connections:
+5V: +5V.1, C3.2, IC2.1 (CONTROL), IC2.6 (VIN)
BT_RX_3_3: C2.2, IC1.13 (13.RX), R2.2, R3.1
BT_TX: CPU_RX1.1, IC1.14 (14.TX)
GND: C1.1, C3.1, C4.2 (M), GND.1, IC1.1 (1.GND), IC1.12 (12.GND), IC1.28 (28.GND), IC1.29 (29.GND), IC2.2 (GND(1)), IC2.5 (GND(2)), R3.2
unnamed: IC1.33 (33.PIO10), MEGA_RST.1
unnamed: IC1.15 (15.RTS), IC1.16 (16.CTS)
unnamed: C2.1, CPU_TX1.1, R2.1
unnamed: IC1.5 (5.RESET), R1.1
VDD: C1.2, C4.1, IC1.11 (11.VDD), IC2.4 (VOUT), R1.2

Board: 2 copper layers, 17.5 x 32.5 mm, 14 parts (2 on the bottom side), 9 nets.

## EAGLE design doc/tracer_for_get_matlab/hardware/tracer-main.brd

Parts:
+5V: TP-HOLE
A1, A2: TP; TP-SQUARE
C1: 22u; 3216
C2, C3, C8, C9, C10, C11, C12, C13, C14: 0.1u; 1608NEW
C5: N.M; 1608NEW
C6, C7: N.M; 1005
CPU_RX: TP-HOLE
CPU_TX: TP-HOLE
D1: 1A/23V/620mV; SOD-323
D10, D13, D42: (PAS)LED[1608]; 1608LED
D14_TX1: TP; TP-SQUARE
D24, D53: (SW)USER_SW(AKIDUKI); SKRPACE010-PAC
GND: TP-HOLE
IC1, IC2: SN74HC4066PW; SOP65P640X120-14N
IC3: (3.3V)VX07803-500; VX07803-PAC
IC4: ATMEGA2560-15AU; TQFP100
ICSP: ICSP; 2X03
J1: B2B-PH; B2B-PH-PAC
J2, J3: B6B-ZR-3.4_LF__SN_; B6BZR34LFSN
MEGA_RST: TP-HOLE
MOD1: (MOD)LINE-TRACER; 8CH-LINETRACER-MOD
MOD2: (MOD)AE-BMX055; MOD-BMX055
MOD3: (MOD)AE-DRV8835; AE-DRV8835
POW: (PAS)LED[1608]; 1608LED
PWM10, PWM11, PWM12: TP; TP-SQUARE
Q1: FET-PCH(SSM3J130TU); SOT65P210X75-3N
R1, R4, R12, R21: 4.7k; 1608NEW
R2, R3: 10k; 1608NEW
R5: N.M; 1005
R6, R19, R20, R22: 1k; 1608NEW
R7, R8, R9, R10, R13: 0; 1608NEW
R11: (PAS)R[1608]; 1608NEW
R14, R15, R16, R17, R18: 30; 1608NEW
RST: (SW)USER_SW(AKIDUKI); SKRPACE010-PAC
RX2: TP; TP-SQUARE
SW1: MSK12C01
TX2: TP; TP-SQUARE
X1: 16MHZ; AWSCR8

Connections:
+5V: +5V.1, C1.1, C2.2, C3.2, C10.2, C11.2, C12.2, C13.2, D1.C, IC1.14 (VCC), IC2.14 (VCC), IC3.3 (3.VOUT), IC4.10 (VCC), IC4.31 (VCC1), IC4.61 (VCC2), IC4.80 (VCC3), ICSP.2, J2.2, J3.2, MOD1.V (5V), MOD2.6 (6.VCC), MOD3.12 (12.VCC), POW.1 (+), R2.2, R3.2, R4.2, R6.2, R12.2, R21.2
ADC0: IC4.97 ((ADC0)PF0), R18.1
ADC1: A1.1, IC4.96 ((ADC1)PF1)
ADC2: A2.1, IC4.95 ((ADC2)PF2)
ADC3: IC4.94 ((ADC3)PF3)
ADC4: IC4.93 ((ADC4/TCK)PF4)
ADC5: IC4.92 ((ADC5/TMS)PF5)
ADC6: IC4.91 ((ADC6/TDO)PF6)
ADC7: IC4.90 ((ADC7/TDI)PF7)
ADC9: IC4.88 (PK1(ADC9/PCINT17))
ADC10: IC4.87 (PK2(ADC10/PCINT18))
ADC11: IC4.86 (PK3(ADC11/PCINT19))
ADC12: IC4.85 (PK4(ADC12/PCINT20))
ADC13: IC4.84 (PK5(ADC13/PCINT21))
ADC14: IC4.83 (PK6(ADC14/PCINT22))
ADC15: IC4.82 (PK7(ADC15/PCINT23))
AREF: C8.2, IC4.98 (AREF)
AVCC: C9.2, IC4.100 (AVCC), R6.1
GND: C1.2 (M), C2.1, C3.1, C5.2, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, D24.2, D24.4, D53.2, D53.4, GND.1, IC1.7 (GND), IC2.7 (GND), IC3.2 (2.GND), IC4.11 (GND), IC4.32 (GND1), IC4.62 (GND2), IC4.81 (GND3), IC4.99 (AGND), ICSP.6, J1.M, J2.5, J3.5, MOD1.G (GND), MOD2.1 (1.GND), MOD3.6 (6.GND), MOD3.11 (11.MODE), R11.1, R13.1, R13.2, R19.1, R20.1, R22.1, RST.2, RST.4, SW1.2, X1.2
M1+: J2.1, MOD3.2 (2.AOUT1)
M1-: J2.6, MOD3.3 (3.AOUT2)
M2+: J3.1, MOD3.4 (4.BOUT1)
M2-: J3.6, MOD3.5 (5.BOUT2)
MEGA_RST: C5.1, C14.2, D1.A, IC4.30 (RESET), ICSP.5, R4.1, RST.1, RST.3
unnamed: IC1.11 (4A), MOD1.1
unnamed: IC1.8 (3A), MOD1.2
unnamed: IC1.4 (2A), MOD1.3
unnamed: IC1.1 (1A), MOD1.4
unnamed: IC2.11 (4A), MOD1.5
unnamed: IC2.8 (3A), MOD1.6
unnamed: IC2.4 (2A), MOD1.7
unnamed: IC2.1 (1A), MOD1.8
unnamed: J1.P, Q1.2 (S), R1.2
unnamed: Q1.1 (G), R1.1, SW1.1
unnamed: C14.1, MEGA_RST.1
unnamed: MOD3.10 (10.AIN1), R14.1
unnamed: C6.2, IC4.33 (XTAL2), R5.1, X1.1
unnamed: C7.2, IC4.34 (XTAL1), R5.2, X1.3
unnamed: MOD3.9 (9.AIN2), R15.1
unnamed: MOD3.8 (8.BIN1), R16.1
unnamed: MOD3.7 (7.BIN2), R17.1
unnamed: POW.2 (-), R19.2
unnamed: D13.2 (-), R20.2
unnamed: D42.2 (-), R22.2
unnamed: D10.2 (-), R11.2
PA0: IC4.78 ((AD0)PA0)
PA1: IC4.77 ((AD1)PA1)
PA2: D24.1, IC4.76 ((AD2)PA2), R21.1
PA3: IC4.75 ((AD3)PA3)
PA4: IC4.74 ((AD4)PA4)
PA5: IC4.73 ((AD5)PA5)
PA6: IC4.72 ((AD6)PA6)
PA7: IC4.71 ((AD7)PA7)
PB0: D53.1, IC4.19 ((SS/PCINT0)PB0), R12.1
PB1: IC4.20 ((SCK/PCINT1)PB1), ICSP.3
PB2: IC4.21 ((MOSI/PCINT2)PB2), ICSP.4
PB3: IC4.22 ((MISO/PCINT3)PB3), ICSP.1
PB4_PWM10: IC4.23 ((OC2A/PCINT4)PB4), PWM10.1
PB5_PWM11: IC4.24 ((OC1A/PCINT5)PB5), PWM11.1
PB6_PWM12: IC4.25 ((OC1B/PCINT6)PB6), PWM12.1
PB7_PWM13: D13.1 (+), IC4.26 ((OC0A/OC1C/PCINT7)PB7)
PC0: IC4.53 ((A8)PC0)
PC1: IC4.54 ((A9)PC1)
PC2: IC4.55 ((A10)PC2)
PC3: IC4.56 ((A11)PC3)
PC4: IC4.57 ((A12)PC4)
PC5: IC4.58 ((A13)PC5)
PC6: IC4.59 ((A14)PC6)
PC7: IC4.60 ((A15)PC7)
PD2_D19(RXD1): IC4.45 ((RXD1/INT2)PD2), J2.4, R9.1, R9.2
PD3_D18(TXD1): IC4.46 ((TXD1/INT3)PD3), J2.3, R10.1, R10.2
PD7: IC4.50 ((T0)PD7)
PE0_RX0: CPU_RX.1, IC4.2 ((RXD0/PCIN8)PE0)
PE1_TX0: CPU_TX.1, IC4.3 ((TXD0)PE1)
PE3_PWM5: IC4.5 ((OC3A/AIN1)PE3), R15.2
PE4_PWM2: IC4.6 ((OC3B/INT4)PE4), R14.2
PE5_PWM3: IC4.7 ((OC3C/INT5)PE5), R16.2
PG0: D10.1 (+), IC4.51 ((WR)PG0)
PG1: IC4.52 ((RD)PG1)
PG2: IC4.70 ((ALE)PG2)
PG5_PWM4: IC4.1 ((OC0B)PG5), R17.2
PH3_PWM6: IC4.15 (PH3(OC4A))
PH4_PWM7: IC4.16 (PH4(OC4B))
PH5_PWM8: IC4.17 (PH5(OC4C))
PH6_PWM9: IC4.18 (PH6(OC2B))
PJ0_D15(RXD3): IC4.63 (PJ0(RXD3/PCINT9)), J3.3, R8.1, R8.2
PK0_D69_ADC8: IC4.89 (PK0(ADC8/PCINT16)), J3.4, R7.1, R7.2
PL0: IC4.35 (PL0(ICP4))
PL1: IC4.36 (PL1(ICP5))
PL2: IC4.37 (PL2(T5))
PL3: IC4.38 (PL3(OC5A))
PL4: IC4.39 (PL4(OC5B))
PL5: IC4.40 (PL5(OC5C))
PL6: IC4.41 (PL6)
PL7: D42.1 (+), IC4.42 (PL7)
RXD2: IC4.12 (PH0(RXD2)), RX2.1
SCL_D21: IC4.43 ((SCL/INT0)PD0), MOD2.3 (3.SCL), R2.1
SDA_D20: IC4.44 ((SDA/INT1)PD1), MOD2.2 (2.SDA), R3.1
SEL1: IC1.13 (1C)
SEL2: IC1.5 (2C)
SEL3: IC1.6 (3C)
SEL4: IC1.12 (4C)
SEL5: IC2.13 (1C)
SEL6: IC2.5 (2C)
SEL7: IC2.6 (3C)
SEL8: IC2.12 (4C)
SENSE: IC1.2 (1B), IC1.3 (2B), IC1.9 (3B), IC1.10 (4B), IC2.2 (1B), IC2.3 (2B), IC2.9 (3B), IC2.10 (4B), R18.2
TXD2: IC4.13 (PH1(TXD2)), TX2.1
TXD3: D14_TX1.1, IC4.64 (PJ1(TXD3/PCINT10))
VM: IC3.1 (1.VIN), MOD3.1 (1.VM), Q1.3 (D)

Notes on the sheet:
LiPo BAT
POWER
FET as SSM3J130TU(TE85L) RS品番:695-4739
(SCK)
(MISO)
(MOSI)
pwm
(TX0)
(RX0)
(SS)
POW:5V SIGNAL:5V JP6=SHORT JP7=OPEN JP8=OPEN

Board: 2 copper layers, 106.0 x 73.3 mm, 70 parts (5 on the bottom side), 61 nets.

## Commit log

2022-05-12 最初のコミット
2022-05-14 DUALSHOCK4の記事を書いた
2022-06-04 インデックス修正
2022-06-28 ミニ4駆追加
2022-06-28 ロボトレース追加
2022-06-28 インデックス更新
2022-07-21 ロボトレ記事更新
2022-08-16 リサイクル記事アップ
2022-08-16 インデックス更新その他
2022-08-28 recycle更新
2022-09-09 名刺基板ページを開設
2022-09-13 トレーサDOCアップデート
2022-09-13 リモートでいじってみるテスト
2022-09-13 mp4 added
2022-09-13 adjust mp4 link
2023-09-16 m1基板ページ追加

Notices in the files:
parts and their libraries:
SparkFun-DiscreteSemi: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
